# Keil uVision project atk_h743.uvprojx, settings and files
target lwIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h743 +hex
  AfterMake: F:\调试\single_led\main_new\HexBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,CMSIS_device_header=\"stm32h7xx.h\"
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\STM32H7xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\User;..\..\Middlewares\lwip\arch;..\..\Middlewares\lwip;..\..\Middlewares\lwip\src\include;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\Middlewares\lwip\lwip_app;..\..\APP;..\..\INCLUDE;..\..\Hardware\inc;..\..\Middlewares\CJSON;..\..\Middlewares\easybutton;..\..\Middlewares\RTT;..\..\Middlewares\littlefs;..\..\Middlewares\lis3dh;..\..\Middlewares\cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\stm32-v7.sct
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group User
    ../../User/: main.c stm32h7xx_it.c freertos_demo.c fault_test.c SysInfoTest.c demo_spi_flash.c bsp_test.c
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Include
    ../../INCLUDE/: bsp.h appconfig.h
  group App/User
    ../../APP/USER/src/: start.c com.c save.c error.c
  group APP/Task
    ../../APP/TASK/src/: app.c det.c eth.c gsm.c single.c alarm.c print.c
  group APP/Driver
    ../../APP/DRIVER/src/: GPRS.c aht20.c BL0939_SPI.c aht201.c ATGM336H.c BL0906_SPI.c
  group App/Tool
    ../../APP/TOOL/src/: crc.c tool.c
  group APP/Update
    ../../APP/UPDATE/src/: update.c update_gsm.c update_http.c update_lwip.c
  group Hardware
    ../../Hardware/src/: bsp_iwdg.c bsp_cpu_flash.c bsp_led.c bsp_relay.c bsp_key.c bsp_rtc.c bsp_usart1.c bsp_usart2.c bsp_usart3.c bsp_usart4.c bsp_uart5.c bsp_usart6.c bsp_uart7.c bsp_lpuart1.c bsp_timers.c bsp_spi_bus.c bsp_spi_flash.c bsp_uart8.c bsp_core_dwt.c bsp_siic_rh0.c bsp_siic_rh1.c bsp_sspi0.c bsp_hspi4.c bsp_sspi1.c bsp_hspi2.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/ETHERNET/: ethernet.c ethernet_chip.c
  group Middlewares/cjson
    ../../Middlewares/CJSON/: cJSON.c mycJSON.c
  group Middlewares/ebtn
    ../../Middlewares/easybutton/: ebtn.c ebtn_app.c ebtn_APP_Event.c ebtn_APP_HAL.c ebtn_APP_Keys.c
  group Middlewares/littlefs
    ../../Middlewares/littlefs/: lfs.c lfs_port.c lfs_util.c
  group Middlewares/LIS3DH
    ../../Middlewares/lis3dh/: hal_lis3dh.c lis3dh_driver.c lis3dh_iic.c lis3dh_spi.c
  group Middlewares/RTT
    ../../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/lwip/src/api
    ../../Middlewares/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/lwip/src/core
    ../../Middlewares/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/lwip/src/netif
    ../../Middlewares/lwip/src/netif/: ethernet.c
  group Middlewares/lwip/lwip_app
    ../../Middlewares/lwip/lwip_app/: lwip_demo.c
  group Middlewares/lwip/arch
    ../../Middlewares/lwip/arch/: ethernetif.c lwip_comm.c sys_arch.c lwipopts.h lwip_comm.h
  group Middlewares/lwip/app/ping
    ../../Middlewares/lwip/lwip_app/ping/: lwip_ping.c
  group Middlewares/lwip/app/tcp_client
    ../../Middlewares/lwip/lwip_app/tcp_client/: tcp_client.c
  group Middlewares/lwip/app/udp
    ../../Middlewares/lwip/lwip_app/udp_multicast/: udp_multicast.c
  group Middlewares/lwip/app/web
    ../../Middlewares/lwip/lwip_app/web_server/: fs.c httpd.c httpd_cgi.c httpd_cgi_ssi.c httpd_ssi.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../User/: FreeRTOSConfig.h
  group Middlewares/cm_backtrace
    ../../Middlewares/cm_backtrace/: cm_backtrace.c cmb_cfg.h
    ../../Middlewares/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Readme
    ../../: readme.txt Doc.txt
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
